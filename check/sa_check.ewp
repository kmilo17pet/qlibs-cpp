# IAR project sa_check.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: sa_check.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  group (top)
    ../src/: bitfield.cpp crc.cpp ffmath.cpp fis.cpp fisCore.cpp fp16.cpp interp1.cpp ltisys.cpp numa.cpp pid.cpp qlibs.h rms.cpp smoother.cpp tdl.cpp
    ./: main.cpp
  group include
    ../src/include/: algorithm.hpp bitfield.hpp crc.hpp ffmath.hpp fis.hpp fp16.hpp interp1.hpp ltisys.hpp mat.hpp numa.hpp pid.hpp qlibs_types.hpp rms.hpp smoother.hpp tdl.hpp types.hpp
